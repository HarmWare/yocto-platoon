# Add the following to the list of PATHS
FILESEXTRAPATHS:append := "${THISDIR}/files:"

# Add the following to the list of SRC_URI
SRC_URI += "file://boot.cmd.in"
